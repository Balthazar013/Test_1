# IAR project BBridge.ewp, settings and files
configuration CC2540_PAD (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: OSALMEM_METRICS=FALSE; xINT_HEAP_LEN=1400; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HMI_SPI_SLAVE=TRUE; HAL_UART=FALSE; HAL_UART_PORT=FALSE; OSAL_SNV=2; xORU_B1; PAD_B3; HMI_SPI_SLAVE=TRUE; HAL_UART=TRUE; xHAL_UART_DMA=1; HAL_UART_SPI=3; HAL_UART_PORT=TRUE; TARGET_PAD; HAL_ADC=FALSE; HAL_AES=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\TI\common; ..\..\TI\include; ..\..\TI\Components\hal\include; ..\..\TI\Components\hal\target\CC2540BBridge; ..\..\TI\Components\osal\include; ..\..\TI\Components\services\saddr; ..\..\TI\Components\ble\include; ..\..\TI\Components\ble\controller\CC254x\phy; ..\..\TI\Components\ble\controller\CC254x\include; ..\..\TI\Components\ble\hci; ..\..\TI\Components\ble\host; ..\..\TI\Components\ble\ROM; ..\..\TI\common\cc2540; ..\..\TI\common\npi\npi_np; ..\..\TI\Profiles\Roles\CC254x; ..\..\TI\Profiles\Roles; ..\..\TI\Profiles\BBridgeProfile\CC254x; ..\..\TI\Profiles\BBridgeProfile; ..\BBridgeModules\src\; APP; ..\..\TI\Profiles\DevInfo
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\TI\common\cc2540\ti_51ew_cc2540b_FBL.xcl
configuration CC2540_ORU (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: OSALMEM_METRICS=FALSE; xINT_HEAP_LEN=1400; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HMI_SPI_SLAVE=TRUE; HAL_UART=FALSE; HAL_UART_PORT=FALSE; OSAL_SNV=2; ORU_B1; xPAD_B0; xPAD_B3; HMI_SPI_SLAVE=TRUE; HAL_UART=TRUE; xHAL_UART_DMA=1; HAL_UART_SPI=3; HAL_UART_PORT=TRUE; POWER_SAVING; TARGET_ORU; HAL_ADC=FALSE; HAL_AES=FALSE
  group APP
    ../Source/: bbridge.c bbridge.h bbridge_Main.c buildversion.h Connectable.c Connectable.h OSAL_BBridge.c Scanner.c Scanner.h USARTInterface.c USARTInterface.h
  group BBridgeModules
    ../BBridgeModules/src/: BBridgeApp.c BBridgeApp.h BBridgeCommons.c BBridgeCommons.h BBridgeDefs.h ConnectableMode.c ConnectableMode.h DataHandler.c DataHandler.h FifoBuffer.c FifoBuffer.h IdleMode.c IdleMode.h ScannerMode.c ScannerMode.h SPITransportLayer.c SPITransportLayer.h typedefs.h
  group HAL/Common
    ../../TI/Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../TI/Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_rpc.h hal_sleep.h hal_timer.h
    ../../TI/Components/services/saddr/: saddr.h
  group HAL/Target/CC2541BBridge/Config
    ../../TI/Components/hal/target/CC2540BBridge/: hal_board_cfg.h
  group HAL/Target/CC2541BBridge/Drivers
    ../../TI/Components/hal/target/CC2540BBridge/: hal_crc.c hal_dma.c hal_flash.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2541BBridge/Includes
    ../../TI/Components/hal/target/CC2540BBridge/: hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../TI/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../TI/Components/ble/host/: linkdb.h
    ../../TI/Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../TI/common/npi/npi_np/: npi.h
  group LIB
    ../../TI/Libraries/CC2540DB/: CC2540_BLE.lib
    ../../TI/Libraries/CC2541DB/bin/: CC2541_BLE.lib
    ../../TI/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../TI/common/npi/npi_np/: npi.c
  group OSAL
    ../../TI/Components/ble/include/: bcomdef.h
    ../../TI/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../TI/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../TI/Profiles/BBridgeProfile/CC254x/: BBridgeGATTprofile.c BBridgeGATTprofile.h
    ../../TI/Profiles/Roles/CC254x/: central.c central.h peripheral.c peripheral.h
    ../../TI/Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../TI/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../TI/Include/: gapgattserver.h gattservapp.h
    ../../TI/Components/ble/host/: gatt_uuid.c
    ../../TI/Profiles/GATT/: gattservapp_util.c
  group TOOLS
    ../../TI/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../TI/common/cc2540/: OnBoard.c OnBoard.h
