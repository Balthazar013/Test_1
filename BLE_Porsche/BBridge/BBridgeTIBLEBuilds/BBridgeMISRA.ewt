<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\BBridgeApp.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\BBridgeApp.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\BBridgeCommons.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\BBridgeCommons.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\BBridgeDefs.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\ConnectableMode.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\ConnectableMode.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\DataHandler.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\DataHandler.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\FifoBuffer.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\FifoBuffer.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\IdleMode.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\IdleMode.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\ScannerMode.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\ScannerMode.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\SPITransportLayer.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\SPITransportLayer.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\BBridgeModules\src\typedefs.h</name>
  </file>
</project>


