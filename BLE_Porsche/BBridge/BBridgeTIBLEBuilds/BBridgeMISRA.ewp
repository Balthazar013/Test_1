# IAR project BBridgeMISRA.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_plain_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ../BBridgeModules/src/: BBridgeApp.c BBridgeApp.h BBridgeCommons.c BBridgeCommons.h BBridgeDefs.h ConnectableMode.c ConnectableMode.h DataHandler.c DataHandler.h FifoBuffer.c FifoBuffer.h IdleMode.c IdleMode.h ScannerMode.c ScannerMode.h SPITransportLayer.c SPITransportLayer.h typedefs.h
    ./: main.c
